options:
  parameters:
    generate_options: qt_gui
    id: TYP
    output_language: python
    title: WiFi Camera
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '800000000'
  states: {}
- name: centre_freq
  id: variable
  parameters:
    value: '2440000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '30720000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\louis\GNURadio\Complex.bin
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bandwidth
    fc: centre_freq
    fftsize: '1024'
    grid: 'True'
    name: Graph
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: bandwidth
    center_freq: centre_freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [soapy_bladerf_source_0, '0', blocks_throttle2_0, '0']
- [soapy_bladerf_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
