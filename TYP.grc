options:
  parameters:
    generate_options: qt_gui
    id: TYP
    output_language: python
    title: WiFi Camera
  states: {}

blocks:
- name: bandwidth
  id: variable
  parameters:
    value: '800000000'
  states: {}
- name: centre_freq
  id: variable
  parameters:
    value: '2440000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '10000000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '50000'
    max_iter: '4000'
    scale: '20'
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '100000'
    max_iter: '100000'
    scale: '0.000001'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bandwidth
    fc: centre_freq
    fftsize: '1024'
    grid: 'True'
    type: float
    ymax: '30'
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '27'
    size: '2048'
    type: float
    xmax: '100'
    xmin: '-100'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '100'
    min: '-100'
    type: float
  states: {state: disabled}
- name: soapy_bladerf_source_0
  id: soapy_bladerf_source
  parameters:
    bandwidth: bandwidth
    center_freq: centre_freq
    gain: '10.0'
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: soapy_bladerf_source_1
  id: soapy_bladerf_source
  parameters:
    bandwidth: bandwidth
    center_freq: centre_freq
    gain: '10.0'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5000
    timeout: '100'
    type: float
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_complex_to_real_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_1, '0', blocks_nlog10_ff_1, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_0, '0']
- [blocks_nlog10_ff_1, '0', zeromq_pub_sink_0, '0']
- [soapy_bladerf_source_0, '0', blocks_conjugate_cc_0, '0']
- [soapy_bladerf_source_0, '0', blocks_multiply_xx_0, '0']
- [soapy_bladerf_source_1, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
